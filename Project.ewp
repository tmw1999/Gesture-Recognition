# IAR project Project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: D:\work\项目\程序\Project\bsp\inr; D:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\430\inc\dlib\c; D:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\430\inc; D:\MSP430F5529程序-单路\MSP430F5529Project\Project\bsp\inr
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: D:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\430\inc; D:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\430\inc\dlib\c; D:\MSP430F5529程序-单路\MSP430F5529Project\Project\bsp\inr
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    bsp/src/: bsp.c bsp_fdc2214.c bsp_iic.c bsp_sysclk.c bsp_uart.c
    ./: main.c
